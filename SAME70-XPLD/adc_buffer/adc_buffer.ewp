# IAR project adc_buffer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: __SAME70Q21B__; F_CPU=300000000
  ICCARM.CCIncludePath2: ; config; examples; hal\include; hal\utils\include; hpl\core; hpl\pio; hpl\pmc; hpl\spi; hpl\xdmac; hri; ; CMSIS\Core\Include; same70b\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAME70Q21B__
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: adc_buffer.out
  ILINK.IlinkIcfFile: same70b\iar\config\linker\Microchip\atsame70q21b\flash.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAME70Q21B__; F_CPU=300000000
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: adc.c adc.h atmel_start.c atmel_start.h atmel_start_pins.h driver_init.c driver_init.h main.c spi.c spi.h xdmac.c xdmac.h
  group src/CMSIS/Core/Include
    CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group src/config
    config/: hpl_pmc_config.h hpl_spi_config.h hpl_xdmac_config.h peripheral_clk_config.h
  group src/examples
    examples/: driver_examples.c driver_examples.h
  group src/hal/include
    hal/include/: hal_atomic.h hal_delay.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hal_spi_s_async.h hpl_core.h hpl_delay.h hpl_dma.h hpl_ext_irq.h hpl_gpio.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_reset.h hpl_sleep.h hpl_spi.h hpl_spi_async.h hpl_spi_dma.h hpl_spi_m_async.h hpl_spi_m_dma.h hpl_spi_m_sync.h hpl_spi_s_async.h hpl_spi_s_sync.h hpl_spi_sync.h
  group src/hal/src
    hal/src/: hal_atomic.c hal_delay.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c hal_spi_s_async.c
  group src/hal/utils/include
    hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h utils_ringbuffer.h
  group src/hal/utils/src
    hal/utils/src/: utils_assert.c utils_event.c utils_list.c utils_ringbuffer.c
  group src/hpl/core
    hpl/core/: hpl_core_m7_base.c hpl_core_port.h hpl_init.c
  group src/hpl/pio
    hpl/pio/: hpl_gpio_base.h
  group src/hpl/pmc
    hpl/pmc/: hpl_pmc.c hpl_pmc.h hpl_sleep.c
  group src/hpl/spi
    hpl/spi/: hpl_spi.c hpl_spi_base.h
  group src/hpl/xdmac
    hpl/xdmac/: hpl_xdmac.c
  group src/hri
    hri/: hri_acc_e70b.h hri_aes_e70b.h hri_afec_e70b.h hri_chipid_e70b.h hri_dacc_e70b.h hri_e70b.h hri_efc_e70b.h hri_gmac_e70b.h hri_gpbr_e70b.h hri_hsmci_e70b.h hri_i2sc_e70b.h hri_icm_e70b.h hri_isi_e70b.h hri_lockbit_e70b.h hri_matrix_e70b.h hri_mcan_e70b.h hri_pio_e70b.h hri_pmc_e70b.h hri_pwm_e70b.h hri_qspi_e70b.h hri_rstc_e70b.h hri_rswdt_e70b.h hri_rtc_e70b.h hri_rtt_e70b.h hri_sdramc_e70b.h hri_smc_e70b.h hri_spi_e70b.h hri_ssc_e70b.h hri_supc_e70b.h hri_tc_e70b.h hri_trng_e70b.h hri_twihs_e70b.h hri_uart_e70b.h hri_usart_e70b.h hri_usbhs_e70b.h hri_utmi_e70b.h hri_wdt_e70b.h hri_xdmac_e70b.h
  group src/same70b/iar
    same70b/iar/: system_same70q21b.c
  group src/same70b/iar/iar
    same70b/iar/iar/: startup_same70q21b.c
  group src/same70b/include
    same70b/include/: component-version.h sam.h same70j19b.h same70j20b.h same70j21b.h same70n19b.h same70n20b.h same70n21b.h same70q19b.h same70q20b.h same70q21b.h system_same70.h
  group src/same70b/include/component
    same70b/include/component/: acc.h aes.h afec.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc.h icm.h isi.h matrix.h mcan.h pio.h pmc.h pwm.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi.h ssc.h supc.h tc.h trng.h twihs.h uart.h usart.h usbhs.h utmi.h wdt.h xdmac.h
  group src/same70b/include/component/deprecated
    same70b/include/component/deprecated/: tc.h template.h usart.h usbhs.h
  group src/same70b/include/instance
    same70b/include/instance/: acc.h aes.h afec0.h afec1.h chipid.h dacc.h efc.h gmac.h gpbr.h hsmci.h i2sc0.h i2sc1.h icm.h isi.h matrix.h mcan0.h mcan1.h pioa.h piob.h pioc.h piod.h pioe.h pmc.h pwm0.h pwm1.h qspi.h rstc.h rswdt.h rtc.h rtt.h sdramc.h smc.h spi0.h spi1.h ssc.h supc.h tc0.h tc1.h tc2.h tc3.h trng.h twihs0.h twihs1.h twihs2.h uart0.h uart1.h uart2.h uart3.h uart4.h usart0.h usart1.h usart2.h usbhs.h utmi.h wdt.h xdmac.h
  group src/same70b/include/pio
    same70b/include/pio/: same70j19b.h same70j20b.h same70j21b.h same70n19b.h same70n20b.h same70n21b.h same70q19b.h same70q20b.h same70q21b.h
